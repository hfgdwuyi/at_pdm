# Keil uVision project Project.uvprojx, settings and files
target AT_PDM (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Test +hex
  AfterMake: fromelf.exe --bin -o "@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM324x9I_EVAL
  c include: ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\BSP\STM324x9I_EVAL;..\Inc;..\CanFestival\driver;..\CanFestival\inc;..\CanFestival\driver\stm32;..\lwip\lwip-1.4.1\src\core;..\module;..\lwip;..\lwip\arch;..\lwip\lwip-1.4.1\src\include;..\lwip\lwip-1.4.1\src\include\ipv4;..\lwip\lwip-1.4.1\src\include\lwip;..\lwip\lwip-1.4.1\src\include\netif;..\lwip\lwip_app\lwip_comm;..\core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Source
    ../Src/: main.c stm32f4xx_it.c App_CAN.c App_GPIO.c App_UART.c Driver_can.c Driver_gpio.c Driver_timer.c Driver_uart.c Driver_wdog.c PDS_PeripheralKSZ8081.c PDS_SocETHERNET.c PDS_SocTICK.c PDS_SocETHERNET_IRQ.c App_FMC.c
  group HAL
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c
  group CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./: startup_stm32f429xx.s
  group Doc
    ../: readme.txt
  group CANOpen
    ../CanFestival/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
    ../CanFestival/driver/stm32/: stm32_canfestival.c MySlave.c MyMaster.c
  group module
    ../module/: GM_Malloc.c GM_Queue.c
  group snmp
    ../lwip/lwip-1.4.1/src/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
  group core
    ../core/: soc_f4_config.c stm32f4x7_eth.c
  group lwip_app
    ../lwip/arch/: sys_arch.c
    ../lwip/lwip_app/lwip_comm/: lwip_comm.c
  group lwip_1.4.1
    ../lwip/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lwip/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_sys.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../lwip/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
software components: CMSIS:CORE 4.1.0
